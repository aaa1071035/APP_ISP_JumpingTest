# Keil uVision project ISP.uvprojx, settings and files
target ISP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISP +hex
  AfterMake: fromelf.exe --bin -o   ./ISP/obj/ISP_part.bin ./ISP/obj/ISP.axf
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=1,0xff --output ./ISP/obj/ISP.bin  !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\stm32f2xx_hal\Inc;.\ISP\Src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x800c000 size 0x54000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ISP\obj\ISP.sct
  link misc: --entry Reset_Handler
--keep=APP_bin.o
  group Src
    ./ISP/Src/: main.c ISP.h ISP.c System_config.c IVT_Test.c
  group bin
    ./ISP/Src/: APP_bin.s
  group MDK-ARM
    ./ISP/Src/: startup_stm32f207xx_isp.s system_stm32f2xx_isp.c
  group STM32F2xx_hal
    ./stm32f2xx_hal/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
