# Keil uVision project APP.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP
  AfterMake: fromelf.exe --bin -o   ./APP/obj/APP_part.bin ./APP/obj/APP.axf
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=0,0xff --output ./APP/obj/APP.bin  !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\APP_ISP_test;.\stm32f2xx_hal\Inc;.\APP\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x800c000 size 0x54000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\APP\obj\APP.sct
  link misc: --entry Reset_Handler
--keep=ISP_bin.o
--keep=ISP2_bin.o
  group Src
    ./APP/Src/: main.c ISP.c ISP.h System_config.c IVT_Test.h
    ./ISP/Src/: IVT_Test.c
  group bin
    ./APP/Src/: ISP_bin.s ISP2_bin.s
  group MDK-ARM
    ./APP/Src/: startup_stm32f207xx_app.s
    ../../../APP_ISP_JUMP/20240313_3/APP_ISP_test/APP/Src/: system_stm32f2xx_app.c
  group STM32F2xx_hal
    ./stm32f2xx_hal/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
